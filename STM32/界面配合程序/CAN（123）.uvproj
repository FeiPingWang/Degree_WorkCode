# Keil uVision project CAN（123）.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CAN（123） +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: .\Core;.\Fwilb\inc;.\Fwilb\src;.\user
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: cantx.c HardWare.c main.c printf.c stm32f10x_it.c Time.c pwm.c
    ./: Time1.c
  group Fwlib
    ./Fwilb/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ./Core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_cl.s stm32f10x_conf.h system_stm32f10x.h
